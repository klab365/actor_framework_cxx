## zephyr/Kconfig
```kconfig
# Copyright (c) 2026 IPC Actor Framework contributors
# SPDX-License-Identifier: Apache-2.0

rsource "../src/port/zephyr/Kconfig"
```
